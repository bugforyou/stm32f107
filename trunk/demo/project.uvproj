# Keil uVision project project.uvproj, settings and files
target RT-Thread UET STM32F107 (ARM-ADS)
  device: STM32F107xC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rtthread-stm32
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL,
  c misc: --diag_suppress=870
  c include: ..\STM32F10x_Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\STM32F10x_Libraries\CMSIS\Core\CM3;..\STM32F10x_Libraries\STM32F10x_StdPeriph_Driver\inc;.;..\kernel\include;..\kernel\libcpu\arm\stm32;..\kernel\finsh;..\kernel\net\lwip\src;..\kernel\net\lwip\src\include;..\kernel\net\lwip\src\arch\include;..\kernel\net\lwip\src\include\ipv4;..\kernel\filesystem\dfs;..\kernel\filesystem\dfs\include;..\kernel\rtgui\include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./: stm32f10x_it.c board.c application.c startup.c led.c usart.c rtconfig.h board.h stm32_eth.c rtc.c msd.c stm3210c_eval_lcd.c today.c info.c key.c picture.c osc.c device_info.c
  group StdPeriph_Driver
    ../STM32F10x_Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_wwdg.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c misc.c
  group CMSIS
    ../STM32F10x_Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../STM32F10x_Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Kernel
    ../kernel/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group STM32
    ../kernel/libcpu/arm/stm32/: cpu.c fault.c interrupt.c stack.c context_rvds.S fault_rvds.S start_rvds.s serial.c
  group LwIP
    ../kernel/net/lwip/src/core/: dhcp.c dns.c init.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c memp.c
    ../kernel/net/lwip/src/core/ipv4/: ip_frag.c autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c
    ../kernel/net/lwip/src/api/: tcpip.c api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c
    ../kernel/net/lwip/src/netif/: ethernetif.c etharp.c
    ../kernel/net/lwip/src/arch/: sys_arch_init.c sys_arch.c
  group finsh
    ../kernel/finsh/: symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c
  group Filesystem
    ../kernel/filesystem/dfs/src/: dfs_util.c dfs_fs.c dfs_init.c dfs_posix.c dfs_raw.c
    ../kernel/filesystem/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group RTGUI
    ../kernel/rtgui/server/: topwin.c driver.c mouse.c panel.c server.c
    ../kernel/rtgui/common/: asc12font.c asc16font.c color.c dc.c dc_buffer.c dc_hw.c filerw.c font.c image.c image_hdc.c image_xpm.c region.c rtgui_object.c rtgui_system.c rtgui_theme.c hz16font.c hz12font.c font_hz_file.c
    ../kernel/rtgui/widgets/: workbench.c box.c button.c container.c iconbox.c label.c textbox.c title.c toplevel.c view.c widget.c window.c checkbox.c filelist_view.c list_view.c progressbar.c radiobox.c slider.c staticline.c
